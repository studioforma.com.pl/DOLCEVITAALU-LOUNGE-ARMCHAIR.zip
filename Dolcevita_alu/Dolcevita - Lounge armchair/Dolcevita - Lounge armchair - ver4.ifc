Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Dolcevita - Lounge armchair - ver4.ifc
Time: 2024-01-11T17:14:56
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (31)
Name
 | Dolcevita - Lounge armchair model_0 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_1 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_2 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_3 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_4 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_5 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_6 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_7 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_8 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_9 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_10 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_11 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_12 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_13 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_14 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_15 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_16 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_17 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_18 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_19 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_20 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_21 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_22 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_23 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_24 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_25 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_26 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_27 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_28 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_29 - ObjectType: SketchupGroup
 | Dolcevita - Lounge armchair model_30 - ObjectType: SketchupGroup
